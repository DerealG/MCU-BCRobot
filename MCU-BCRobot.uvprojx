# Keil uVision project MCU-BCRobot.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MCU-BCRobot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\src\main;.\src\sys;.\src\HARDWARE;.\src\Control;.\src\HARDWARE\ADC;.\src\HARDWARE\ENCODER;.\src\HARDWARE\MOTOR;.\src\Interface\IIC;.\src\Interface\Uart;.\src\MPU6050;.\src\PID_Debug
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./src/main/: main.c
  group HARDWARE
    ./src/HARDWARE/ADC/: adc.c adc.h
    ./src/HARDWARE/ENCODER/: encoder.c encoder.h
    ./src/HARDWARE/MOTOR/: motor.c motor.h
  group sys
    ./src/sys/: sys.c sys.h delay.c delay.h
  group control
    ./src/Control/: control.c control.h
  group Interface
    ./src/Interface/IIC/: IOI2C.c IOI2C.h
    ./src/Interface/Uart/: uart.c uart.h
  group MPU6050
    ./src/MPU6050/: dmpKey.h dmpmap.h filter.c filter.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h MPU6050.c mpu6050.h
  group PID_Debug
    ./src/PID_Debug/: DataScope_DP.C DataScope_DP.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
